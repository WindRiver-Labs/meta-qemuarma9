# WR qemuarma9 configuration, not supported in Yocto
KBRANCH_qemuarma9 ?= "v4.14/standard/arm-versatile-926ejs"
KERNEL_DEVICETREE_qemuarma9 = "vexpress-v2p-ca9.dtb"
COMPATIBLE_MACHINE_qemuarma9 = "qemuarma9"
