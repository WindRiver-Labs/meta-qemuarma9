TARGET_SUPPORTED_KTYPES = "standard preempt-rt"
