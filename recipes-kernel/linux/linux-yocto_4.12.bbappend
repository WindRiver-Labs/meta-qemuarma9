TARGET_SUPPORTED_KTYPES_qemuarma9 = "standard"

KERNEL_DEVICETREE_qemuarma9 = "vexpress-v2p-ca9.dtb"

KBRANCH_qemuarma9_standard ?= "standard/arm-versatile-926ejs"
