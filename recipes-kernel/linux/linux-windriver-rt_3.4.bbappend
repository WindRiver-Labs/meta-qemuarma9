include linux-windriver-qemu.inc

TARGET_SUPPORTED_KTYPES += " preempt-rt"

