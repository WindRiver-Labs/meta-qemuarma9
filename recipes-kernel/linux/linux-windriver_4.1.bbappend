TARGET_SUPPORTED_KTYPES_qemuarma9 = "standard"

KERNEL_DEVICETREE_qemuarma9 = "vexpress-v2p-ca9.dtb"
